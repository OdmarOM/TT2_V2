# Keil uVision project Ramh.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ramh
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\Include;.\Objects;.\RTE\Device\STM32F103RB;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.0.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --show_parent_lib --show_full_path
  group Source Code
    ./Source/: main.cpp Robot.cpp User.cpp Routine.cpp
    ./source/: OsObjects.cpp Trajectory.cpp Phase.cpp Joint.cpp Motor.cpp Linker.cpp
  group Hardware Code
    ./Source/: Delay.c Init.cpp Usart.cpp retarget.c
    ./source/: HardwareInit.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX 4.81.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
